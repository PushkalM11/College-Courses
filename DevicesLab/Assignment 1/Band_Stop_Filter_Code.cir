Band Stop Filter

*This code simulates a Band Stop filter using-
*A Low Pass filter and a High Pass filter in series.
*The cutoff frequencies are 58Hz and 48000Hz

*High Pass filter components-
C1 1 2 2.744u
R1 2 4 1k

*Low Pass filter components-
R2 2 3 3.316
C2 3 4 1u

*Resistor component-
R3 4 0 1k

*Voltage Source-
Vin 1 0 dc 0 ac 1

*Control Block-
.control

*Sweep Settings-
ac dec 10 1 10Meg

*Color Settings-
set color0 = white
set color1 = black
set color2 = blue

*Plot Command-
plot vdb(4) xlog ylabel 'Gain (dB)'

.endc
