Band Pass Filter

*This code simulates a Band Bass filter using-
*A Low Pass filter and a High Pass filter in series.
*The cutoff frequencies are 58Hz and 48000Hz

*High Pass filter components-
C1 1 2 2.744u
R1 2 0 1k

*Low Pass filter components-
R2 2 3 3.316
C2 3 0 1u

*Voltage Source-
Vin 1 0 dc 0 ac 1

*Control Block-
.control

*Sweep Settings-
ac dec 10 0.1 10Meg

*Color Settings-
set color0 = white
set color1 = black
set color2 = blue

*Plot Command-
plot vdb(3) xlog ylabel 'Gain (dB)'

.endc
